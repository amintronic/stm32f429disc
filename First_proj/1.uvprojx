# Keil uVision project 1.uvprojx, settings and files
target first-proj (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 1
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./: 1.c
  group ::Board Support
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/Boards/ST/STM32F401C-Discovery/Common/: LED.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.1.1/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/Device/StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/RTE_Driver/: GPIO_STM32F4xx.c
    RTE/Device/STM32F429ZI/: RTE_Device.h startup_stm32f429_439xx.s stm32f4xx_conf.h system_stm32f4xx.c
software components: CMSIS:CORE 3.30.0, CMSIS:DSP 1.4.2, Board Support:STM32F401C-Discovery:LED 1.0.0, Device:GPIO 1.0.1, Device:Startup 1.3.1, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0
